# Keil uVision project 三色LED控制.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 三色LED控制 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\PWM控制LED
  group Source Group 1
    ./: STARTUP.A51 main.c led.c uart.c led.h uart.h
